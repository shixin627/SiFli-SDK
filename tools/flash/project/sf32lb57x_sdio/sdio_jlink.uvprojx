# Keil uVision project sdio_jlink.uvprojx, settings and files
target sdio1 (6210000::V6.21::ARMCLANG)
  device: ARMv8MML_DSP_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("ARMV8MML") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: bf0
  BeforeMake: .\prebuild.bat
  AfterMake: cmd.exe /C copy "build\keil\obj\%L" "..\..\jlink_drv\sf32lb57x_sd\SF32LB57X_EXT_SD1.elf"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SOC_BF0_HCPU, USE_HAL_DRIVER, SF32LB57X, ARM_MATH_LOOPUNROLL,JLINK,JLINK_SDIO_1,HAL_TICK_PER_SECOND=1000,_USE_PRODUCTLINE, CFG_FACTORY_DEBUG
  c misc: -march=armv8-m.main+cdecp1
  c include: .;.\src;..\..\..\..\customer\boards\include;..\..\..\..\drivers\cmsis\sf32lb57x;..\..\..\..\drivers\cmsis\Include;..\..\..\..\external\CMSIS\Include;..\..\..\..\drivers\Include;..\..\..\..\customer\boards\include\config\sf32lb57x;..\..\src;..\..\..\..\middleware\sifli_matrix
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ../../link_scripts/link_jlink.sct
  link misc: --cpu=Cortex-M33 --strict --scatter ../../link_scripts/link_jlink_nand.sct --summary_stderr --info summarysizes --map --load_addr_map_info --xref --callgraph --symbols --info sizes --info totals --info unused --info veneers  --list build/bf0_ap.map  --libpath=C:/Keil_v5/ARM/ARMCLANG/lib --library_type=microlib
  group Applications
    ./src/: FlashDev.c FlashPrg.c sd_nand_ops.c sd_nand_drv.c main.c sd_emmc_ops.c
    ../src/: user_cfg.c
  group CMSIS_BF0
    ../../../../drivers/hal/: flash_table.c
    ../../../../drivers/cmsis/sf32lb57x/Templates/arm/: startup_bf0_hcpu_ac6.S
    ../../../../drivers/cmsis/sf32lb57x/: bf0_pin_const.c
  group BF0_HAL
    ../../../../drivers/hal/: bf0_hal.c bf0_hal_cortex.c bf0_hal_dma.c bf0_hal_pinmux.c bf0_hal_uart.c bf0_hal_rcc.c bf0_hal_hpaon.c bf0_hal_pmu.c bf0_hal_gpio.c bf0_hal_pmu_sf32lb57x.c bf0_hal_hlp.c
target emmc1 (6210000::V6.21::ARMCLANG)
  device: ARMv8MML_DSP_SP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: as above
  output: bf0
  BeforeMake: prebuild.bat
  AfterMake: cmd.exe /C copy "build\keil\obj\%L" "..\..\jlink_drv\sf32lb57x_sd\SF32LB57X_EXT_EMMC1.elf"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SOC_BF0_HCPU, USE_HAL_DRIVER, SF32LB57X, ARM_MATH_LOOPUNROLL,JLINK,JLINK_SDEMMC_1,HAL_TICK_PER_SECOND=1000,_USE_PRODUCTLINE, CFG_FACTORY_DEBUG
  c misc: -march=armv8-m.main+cdecp1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ../../link_scripts/link_jlink.sct
  link misc: as above
