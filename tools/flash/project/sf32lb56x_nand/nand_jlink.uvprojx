# Keil uVision project nand_jlink.uvprojx, settings and files
target nand3 (6140001::V6.14.1::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: bf0
  BeforeMake: .\prebuild.bat
  AfterMake: cmd.exe /C copy "build\keil\obj\%L" "..\..\jlink_drv\sf32lb56x_nand\SF32LB56X_EXT_NAND3.elf"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SOC_BF0_HCPU, USE_HAL_DRIVER, SF32LB56X, ARM_MATH_LOOPUNROLL,JLINK,JLINK_FLASH_3,_USE_PRODUCTLINE,HAL_TICK_PER_SECOND=1000,BSP_USING_BBM,PAGE_SIZE=131072,HAL_USE_NAND,CFG_FACTORY_DEBUG
  c misc: -march=armv8-m.main+cdecp1
  c include: .;.\src;..\..\..\..\customer\boards\butterflite_fpga;..\..\..\..\customer\boards\include;..\..\..\..\drivers\cmsis\sf32lb56x;..\..\..\..\drivers\cmsis\Include;..\..\..\..\external\CMSIS\Include;..\..\..\..\drivers\Include;..\..\..\..\rtos\rtthread\bsp\sifli\drivers\config\sf32lb56x;..\..\..\..\customer\boards\include\config\sf32lb56x;..\..\src;..\..\..\..\middleware\sifli_matrix
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ../../link_scripts/link_jlink_nand.sct
  link misc: --cpu=Cortex-M33 --strict --scatter ../../link_scripts/link_jlink_nand.sct --summary_stderr --info summarysizes --map --load_addr_map_info --xref --callgraph --symbols --info sizes --info totals --info unused --info veneers  --list build/bf0_ap.map  --libpath=C:/Keil_v5/ARM/ARMCLANG/lib --library_type=microlib
  group Applications
    ./src/: FlashDev.c FlashPrg.c main.c
    ../src/: user_cfg.c
  group CMSIS_BF0
    ../../../../drivers/cmsis/sf32lb56x/: bf0_pin_const.c
    ../../../../drivers/hal/: flash_table.c nand_table.c
    ../../../../drivers/cmsis/sf32lb56x/Templates/arm/: startup_bf0_hcpu_ac6.S
  group BF0_HAL
    ../../../../drivers/hal/: bf0_hal.c bf0_hal_cortex.c bf0_hal_dma.c bf0_hal_pinmux.c bf0_hal_uart.c bf0_hal_rcc.c bf0_hal_hpaon.c bf0_hal_pmu.c bf0_hal_gpio.c bf0_hal_lpaon.c bf0_hal_mpi.c bf0_hal_mpi_ex.c sifli_bbm.c bf0_hal_rtc.c bf0_hal_ext_dma.c bf0_hal_hlp.c
  group PMIC
    ./src/: pmic_controller.c
target nand3_bigblk (6140001::V6.14.1::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: bf0
  BeforeMake: .\prebuild.bat
  AfterMake: cmd.exe /C copy "build\keil\obj\%L" "..\..\jlink_drv\sf32lb56x_nand\SF32LB56X_EXT_BIGBLK_NAND3.elf"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SOC_BF0_HCPU, USE_HAL_DRIVER, SF32LB56X, ARM_MATH_LOOPUNROLL,JLINK,JLINK_FLASH_3,_USE_PRODUCTLINE,HAL_TICK_PER_SECOND=1000,BSP_USING_BBM,PAGE_SIZE=262144,HAL_USE_NAND,CFG_FACTORY_DEBUG
  c misc: -march=armv8-m.main+cdecp1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ../../link_scripts/link_jlink_nand.sct
  link misc: as above
target nand3_nobbm (6140001::V6.14.1::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: bf0
  BeforeMake: .\prebuild.bat
  AfterMake: cmd.exe /C copy "build\keil\obj\%L" "..\..\jlink_drv\sf32lb56x_nand\SF32LB56X_EXT_ORG_NAND3.elf"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SOC_BF0_HCPU, USE_HAL_DRIVER, SF32LB56X, ARM_MATH_LOOPUNROLL,JLINK,JLINK_FLASH_3,_USE_PRODUCTLINE,HAL_TICK_PER_SECOND=1000,PAGE_SIZE=131072,HAL_USE_NAND,CFG_FACTORY_DEBUG
  c misc: -march=armv8-m.main+cdecp1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ../../link_scripts/link_jlink_nand.sct
  link misc: as above
target nand3_nobbm_bigblk (6140001::V6.14.1::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: as above
  output: bf0
  BeforeMake: .\prebuild.bat
  AfterMake: cmd.exe /C copy "build\keil\obj\%L" "..\..\jlink_drv\sf32lb56x_nand\SF32LB56X_EXT_ORG_BIGBLK_NAND3.elf"
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SOC_BF0_HCPU, USE_HAL_DRIVER, SF32LB56X, ARM_MATH_LOOPUNROLL,JLINK,JLINK_FLASH_3,_USE_PRODUCTLINE,HAL_TICK_PER_SECOND=1000,PAGE_SIZE=262144,HAL_USE_NAND,CFG_FACTORY_DEBUG
  c misc: -march=armv8-m.main+cdecp1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: ../../link_scripts/link_jlink_nand.sct
  link misc: as above
