# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: main
  AfterMake: postbuild.bat !L
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: USE_FULL_ASSERT, RT_USING_ARM_LIBC, HAVE_LRINTF, SOC_BF0_HCPU, USE_HAL_DRIVER, HAVE_ALLOCA_H, USE_ALLOCA, LCPU_CONFIG_V1, HAL_USE_NAND, FREETYPE_FONT_NAME=tiny55_full, ARM_MATH_LOOPUNROLL, FT2_BUILD_LIBRARY, SIFLI_BUILD="9c1170fc", LV_CONF_KCONFIG_EXTERNAL_INCLUDE=<lv_conf_sifli.h>, FIXED_POINT, SF32LB56X, SIFLI_VERSION=33882112, HAL_TICK_PER_SECOND=1000, __FILE__=__FILE_NAME__, OPUS_BUILD, DISABLE_FLOAT_API, OPUS_CELT_SUPPORT
  c misc: -Wno-builtin-macro-redefined
  c include: build_sf32lb56w-watch_hcpu;..\..\..\..\..\rtos\rtthread\include;..\..\..\..\..\customer\boards\common;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\include\config\sf32lb56x;..\..\..\..\..\customer\boards\eh-lb563;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\sf32lb56-watch;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\sf32lb56w-watch;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\eh-lb56xu;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\common;..\..\..\..\..\customer\peripherals\co5300;..\..\..\..\..\customer\peripherals\common;..\..\..\..\..\customer\peripherals\cst820;..\..\..\..\..\customer\peripherals\common;..\..\..\..\..\customer\peripherals\ft3168;..\..\..\..\..\rtos\rtthread\bsp\sifli\drivers;..\..\..\..\..\drivers\cmsis\sf32lb56x;..\..\..\..\..\drivers\cmsis\Include;..\..\..\..\..\external\CMSIS\Include;..\..\..\..\..\drivers\Include;..\..\..\..\..\drivers\hal_epic_ex;..\..\..\..\..\external\cJSON-1.7.17;..\..\..\..\..\external\CMSIS\CMSIS\Include;..\..\..\..\..\external\CMSIS\cmsis_NN\Source\NNTest;..\..\..\..\..\external\CMSIS\RTOS2\Include;..\..\..\..\..\external\CMSIS\CMSIS\Include;..\..\..\..\..\external\CMSIS\cmsis_NN\Source\NNTest;..\..\..\..\..\external\CMSIS\RTOS2\Include;..\..\..\..\..\external\FlashDB\inc;..\..\..\..\..\external\FlashDB\port\fal\inc;..\..\..\..\..\external\freetype\include;..\..\..\..\..\external\libhelix-mp3;..\..\..\..\..\external\libhelix-mp3\pub;..\..\..\..\..\external\libhelix-mp3\real;..\..\..\..\..\external\lvgl_v8;..\..\..\..\..\external\lvgl_v8\lvgl;..\..\..\..\..\external\lvgl_v8\src;..\..\..\..\..\external\lvgl_v8\src\core;..\..\..\..\..\external\lvgl_v8\src\draw;..\..\..\..\..\external\lvgl_v8\src\extra;..\..\..\..\..\external\lvgl_v8\src\font;..\..\..\..\..\external\lvgl_v8\src\hal;..\..\..\..\..\external\lvgl_v8\src\misc;..\..\..\..\..\external\lvgl_v8\src\widgets;..\..\..\..\..\external\lvgl_v8\src\draw\arm2d;..\..\..\..\..\external\lvgl_v8\src\draw\nxp;..\..\..\..\..\external\lvgl_v8\src\draw\sdl;..\..\..\..\..\external\lvgl_v8\src\draw\sifli_epic;..\..\..\..\..\external\lvgl_v8\src\draw\stm32_dma2d;..\..\..\..\..\external\lvgl_v8\src\draw\sw;..\..\..\..\..\external\lvgl_v8\src\draw\swm341_dma2d;..\..\..\..\..\external\lvgl_v8\src\draw\nxp\pxp;..\..\..\..\..\external\lvgl_v8\src\draw\nxp\vglite;..\..\..\..\..\external\lvgl_v8\src\extra\layouts;..\..\..\..\..\external\lvgl_v8\src\extra\libs;..\..\..\..\..\external\lvgl_v8\src\extra\others;..\..\..\..\..\external\lvgl_v8\src\extra\themes;..\..\..\..\..\external\lvgl_v8\src\extra\widgets;..\..\..\..\..\external\lvgl_v8\src\extra\layouts\flex;..\..\..\..\..\external\lvgl_v8\src\extra\layouts\grid;..\..\..\..\..\external\lvgl_v8\src\extra\libs\bmp;..\..\..\..\..\external\lvgl_v8\src\extra\libs\ffmpeg;..\..\..\..\..\external\lvgl_v8\src\extra\libs\freetype;..\..\..\..\..\external\lvgl_v8\src\extra\libs\fsdrv;..\..\..\..\..\external\lvgl_v8\src\extra\libs\gif;..\..\..\..\..\external\lvgl_v8\src\extra\libs\png;..\..\..\..\..\external\lvgl_v8\src\extra\libs\qrcode;..\..\..\..\..\external\lvgl_v8\src\extra\libs\rlottie;..\..\..\..\..\external\lvgl_v8\src\extra\libs\sjpg;..\..\..\..\..\external\lvgl_v8\src\extra\others\fragment;..\..\..\..\..\external\lvgl_v8\src\extra\others\gridnav;..\..\..\..\..\external\lvgl_v8\src\extra\others\ime;..\..\..\..\..\external\lvgl_v8\src\extra\others\imgfont;..\..\..\..\..\external\lvgl_v8\src\extra\others\monkey;..\..\..\..\..\external\lvgl_v8\src\extra\others\msg;..\..\..\..\..\external\lvgl_v8\src\extra\others\snapshot;..\..\..\..\..\external\lvgl_v8\src\extra\themes\basic;..\..\..\..\..\external\lvgl_v8\src\extra\themes\default;..\..\..\..\..\external\lvgl_v8\src\extra\themes\mono;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\animimg;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\calendar;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\chart;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\colorwheel;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\imgbtn;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\keyboard;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\led;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\list;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\menu;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\meter;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\msgbox;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\span;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\spinbox;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\spinner;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\tabview;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\tileview;..\..\..\..\..\external\lvgl_v8\src\extra\widgets\win;..\..\..\..\..\external\lz4;..\..\..\..\..\external\opus-1.4;..\..\..\..\..\external\opus-1.4\include;..\..\..\..\..\external\opus-1.4\src;..\..\..\..\..\external\opus-1.4\silk;..\..\..\..\..\external\opus-1.4\celt;..\..\..\..\..\external\opus-1.4\silk\fixed;..\..\..\..\..\external\state_machine-latest\inc;..\..\..\..\..\external\TensorFlow-Lite-Micro\src;..\..\..\..\..\external\WebRTC_audio_processing;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\common_audio;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\common_audio\vad\include;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\common_audio\signal_processing;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\common_audio\signal_processing\include;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\modules\audio_processing\ns;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\modules\audio_processing\ns\include;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\system_wrappers\include;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\modules\audio_processing\agc\legacy;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\modules\audio_processing\aecm;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\modules\audio_processing\aecm\include;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\modules\audio_processing\logging;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\modules\audio_processing\utility;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\modules\audio_processing\dc_correction;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\modules\audio_processing\ramp_in;..\..\..\..\..\external\WebRTC_audio_processing\webrtc\modules\audio_processing\ramp_out;..\..\..\..\..\middleware\include;..\..\..\..\..\middleware\button;..\..\..\..\..\middleware\context_backup;..\..\..\..\..\middleware\cpu_usage_profiler;..\..\..\..\..\middleware\ezipa_dec;..\..\..\..\..\middleware\ipc_queue\common;..\..\..\..\..\middleware\ipc_queue\include;..\..\..\..\..\middleware\ipc_queue\porting\os;..\..\..\..\..\middleware\ipc_queue\porting\os\rtthread;..\..\..\..\..\middleware\ipc_queue\porting\sf32lb56x;..\..\..\..\..\middleware\ipc_queue\porting\sf32lb56x\hcpu;..\..\..\..\..\middleware\app_fwk;..\..\..\..\..\middleware\app_fwk\reg_fwk;..\..\..\..\..\middleware\audio;..\..\..\..\..\middleware\audio\include;..\..\..\..\..\middleware\audio;.;..\..\..\..\..\middleware\btdm_internal\plf;..\..\..\..\..\external\libhelix-mp3\pub;..\..\..\..\..\middleware\app_fwk;..\..\..\..\..\middleware\audio\anyka;..\..\..\..\..\middleware\audio\vbe_drc;..\..\..\..\..\middleware\audio\audio_bt_voice;..\..\..\..\..\middleware\audio\audio_local_music;..\..\..\..\..\middleware\audio\audio_manager;..\..\..\..\..\middleware\audio\audio_port;..\..\..\..\..\middleware\audio\audio_speaker_mic;..\..\..\..\..\middleware\audio\audio_voice_proc;..\..\..\..\..\middleware\barcode128;..\..\..\..\..\middleware\bluetooth\service;..\..\..\..\..\middleware\bluetooth\service\ble;..\..\..\..\..\middleware\bluetooth\service\ble\gatt_service;..\..\..\..\..\middleware\bluetooth\service\bt\bt_audio;..\..\..\..\..\middleware\bluetooth\service\bt\bt_cm;..\..\..\..\..\middleware\bluetooth\service\bt\bt_finsh;..\..\..\..\..\middleware\bluetooth\service\common;..\..\..\..\..\middleware\bluetooth\service\ble;..\..\..\..\..\middleware\bluetooth\service\internal;..\..\..\..\..\middleware\bluetooth\include;..\..\..\..\..\middleware\data_bus\public;..\..\..\..\..\middleware\data_bus\include;..\..\..\..\..\rtos\rtthread\components\drivers\sensors;..\..\..\..\..\middleware\lvgl;..\..\..\..\..\middleware\lvgl\lv_ext_resouce;..\..\..\..\..\middleware\lvgl;..\..\..\..\..\middleware\lvgl\lvsf;..\..\..\..\..\middleware\lvgl;..\..\..\..\..\middleware\lvgl\lvsf\gui_widgets;..\..\..\..\..\middleware\lvgl\lvsf\gui_widgets;..\..\..\..\..\middleware\lvgl\lv_drivers;..\..\..\..\..\middleware\lvgl\lvgl_extensions;..\..\..\..\..\middleware\lvgl\gif_dec;..\..\..\..\..\middleware\share_prefs;..\..\..\..\..\middleware\sifli_lib\lib;..\..\..\..\..\middleware\include;..\..\..\..\..\rtos\os_adaptor\src;..\..\..\..\..\rtos\os_adaptor\inc;..\..\src\hcpu\resource\images;build_sf32lb56w-watch_hcpu\src\resource\strings;build_sf32lb56w-watch_hcpu\src\gui_apps;..\..\src\hcpu\gui_apps\app_layout;..\..\src\hcpu\gui_apps\battery;..\..\src\hcpu\gui_apps\clock;..\..\src\hcpu\gui_apps\common;..\..\src\hcpu\gui_apps\game;..\..\src\hcpu\gui_apps\gesture;..\..\src\hcpu\gui_apps\interact;..\..\src\hcpu\gui_apps\main;..\..\src\hcpu\gui_apps\message;..\..\src\hcpu\gui_apps\speech;..\..\src\hcpu\gui_apps\test;..\..\src\hcpu\gui_apps\utils;..\..\src\hcpu\gui_apps\incoming_call;..\..\src\hcpu\gui_apps\onboarding;..\..\src\hcpu;..\..\src\modules\algorithm\AirMouse;..\..\src\modules\algorithm\GestureRecognition;..\..\src\modules\bloc;..\..\src\modules\client;..\..\src\modules\communicate;..\..\src\modules\model;..\..\src\modules\service;..\..\src\modules\tests;..\..\src\modules\util\includes;..\..\..\..\..\rtos\rtthread\libcpu\arm\cortex-m33;..\..\..\..\..\rtos\rtthread\libcpu\arm\common;..\..\..\..\..\rtos\rtthread\components\cplusplus;..\..\..\..\..\rtos\rtthread\components\dfs\include;..\..\..\..\..\rtos\rtthread\components\dfs\filesystems\devfs;..\..\..\..\..\rtos\rtthread\components\dfs\filesystems\elmfat;..\..\..\..\..\rtos\rtthread\components\dfs\filesystems\dhara\dhara;..\..\..\..\..\rtos\rtthread\components\drivers\audio;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\spi;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\sensors;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\finsh;..\..\..\..\..\rtos\rtthread\components\libc\compilers\armlibc;..\..\..\..\..\rtos\rtthread\components\libc\compilers\common\include;..\..\..\..\..\rtos\rtthread\components\utilities\llt_mem;..\..\..\..\..\rtos\rtthread\components\utilities\ulog;..\..\..\..\..\rtos\rtthread\components\utilities\ulog\backend
  asm misc: --cpreproc  --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: build_sf32lb56w-watch_hcpu/link.sct
  link misc: --cpu=cortex-m33 --strict --scatter build_sf32lb56w-watch_hcpu/link.sct --summary_stderr --info summarysizes --map --load_addr_map_info --xref --callgraph --symbols --info sizes --info totals --info unused --info veneers --any_contingency  --list build_sf32lb56w-watch_hcpu/main.map  --libpath=C:/Keil_v5/ARM/ARMCLANG/lib --diag_suppress=L6314 --diag_suppress=L6329 --predefine="-DSF32LB56X" --predefine="-DHAL_TICK_PER_SECOND=1000" --predefine="-DSIFLI_BUILD="9c1170fc"" --predefine="-DUSE_HAL_DRIVER" --predefine="-DUSE_FULL_ASSERT" --predefine="-DSF32LB56X" --predefine="-DLCPU_CONFIG_V1" --predefine="-DHAL_USE_NAND" --predefine="-DSIFLI_VERSION=33882112" --predefine="-DSOC_BF0_HCPU" --predefine="-DARM_MATH_LOOPUNROLL" --predefine="-DFT2_BUILD_LIBRARY" --predefine="-DLV_CONF_KCONFIG_EXTERNAL_INCLUDE=<lv_conf_sifli.h>" --predefine="-DHAVE_ALLOCA_H" --predefine="-DOPUS_BUILD" --predefine="-DFIXED_POINT" --predefine="-DUSE_ALLOCA" --predefine="-DDISABLE_FLOAT_API" --predefine="-DHAVE_LRINTF" --predefine="-DOPUS_CELT_SUPPORT" --predefine="-DFREETYPE_FONT_NAME=tiny55_full" --predefine="-DRT_USING_ARM_LIBC"
  group Kernel
    ../../../../../rtos/rtthread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c memheap2.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Drivers
    ../../../../../customer/boards/common/: bsp_common.c flash.c
    ../../../../../customer/boards/eh-lb56xu/: battery_table.c bsp_init.c bsp_lcd_tp.c bsp_pinmux.c bsp_power.c
    ../../../../../customer/peripherals/co5300/: co5300.c
    ../../../../../customer/peripherals/cst820/: capacitive_hynitron_CST820_update.c cst820.c cst820_update.c
    ../../../../../customer/peripherals/ft3168/: ft3168.c
    ../../../../../rtos/rtthread/bsp/sifli/drivers/: drv_dma.c drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm.c drv_pwm_lptim.c drv_spi.c drv_i2c.c drv_adc.c drv_rtc.c drv_spi_flash.c drv_spi_nand.c drv_sys_cfg.c drv_ext_dma.c drv_wdt.c drv_audprc.c drv_audcodec.c drv_lcd_private.c drv_lcd.c drv_ram_lcd.c drv_lcd_test.c drv_lcd_fb.c drv_touch.c drv_epic.c drv_epic_mask.c drv_psram.c drv_mpi.c drv_aes.c drv_common.c drv_dbg.c
  group CMSIS_BF0
    ../../../../../drivers/cmsis/sf32lb56x/: bf0_pin_const.c lcpu_config_type.c lcpu_patch.c bf0_lcpu_init.c bt_rf_fulcal.c bt_rf_cw_config.c bt_power_config.c bt_afh_test.c
    ../../../../../drivers/cmsis/sf32lb56x/Templates/: system_bf0_ap.c
    ../../../../../drivers/cmsis/sf32lb56x/Templates/arm/: startup_bf0_hcpu.S
  group BF0_HAL
    ../../../../../drivers/hal/: bf0_hal.c bf0_hal_adc.c bf0_hal_aes.c bf0_hal_aes_ns.c bf0_hal_audcodec.c bf0_hal_audprc.c bf0_hal_bleaon.c bf0_hal_busmon.c bf0_hal_can.c bf0_hal_cortex.c bf0_hal_crc.c bf0_hal_dma.c bf0_hal_dsi.c bf0_hal_efuse.c bf0_hal_epic.c bf0_hal_ext_dma.c bf0_hal_ezip.c bf0_hal_facc.c bf0_hal_fft.c bf0_hal_gpio.c bf0_hal_hcd.c bf0_hal_hlp.c bf0_hal_hpaon.c bf0_hal_i2c.c bf0_hal_i2s.c bf0_hal_lcdc.c bf0_hal_lcpu_config.c bf0_hal_lpaon.c bf0_hal_lpcomp.c bf0_hal_lptim.c bf0_hal_lrc_cal.c bf0_hal_mailbox.c bf0_hal_mpi.c bf0_hal_mpi_ex.c bf0_hal_mpi_psram.c bf0_hal_nn_acc.c bf0_hal_patch.c bf0_hal_pcd.c bf0_hal_pdm.c bf0_hal_pinmux.c bf0_hal_pmu.c bf0_hal_psram.c bf0_hal_ptc.c bf0_hal_rcc.c bf0_hal_rng.c bf0_hal_rtc.c bf0_hal_sd_ex.c bf0_hal_sdadc.c bf0_hal_sdhci.c bf0_hal_sdmmc.c bf0_hal_secu.c bf0_hal_spi.c bf0_hal_tim.c bf0_hal_tim_ex.c bf0_hal_tsen.c bf0_hal_uart.c bf0_hal_wdt.c bf0_sys_cfg.c flash_table.c nand_table.c sifli_bbm.c
  group lib_hal_epic_ex
    ../../../../../drivers/hal_epic_ex/: hal_epic_ex_rvds.lib
  group cJSON
    ../../../../../external/cJSON-1.7.17/: cJSON.c cJSON_Utils.c
  group CMSIS_OS
    ../../../../../external/CMSIS/RTOS2/RT-Thread/: cmsis_rtthread.c os_systick.c
  group CMSIS_DSP
    ../../../../../external/CMSIS/cmsis_NN/Source/ActivationFunctions/: arm_nn_activations_q15.c arm_nn_activations_q7.c arm_relu6_s8.c arm_relu_q15.c arm_relu_q7.c
    ../../../../../external/CMSIS/cmsis_NN/Source/BasicMathFunctions/: arm_elementwise_add_s16.c arm_elementwise_add_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s8.c
    ../../../../../external/CMSIS/cmsis_NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s8.c arm_convolve_1x1_HWC_q7_fast_nonsquare.c arm_convolve_1x1_s8_fast.c arm_convolve_HWC_q15_basic.c arm_convolve_HWC_q15_fast.c arm_convolve_HWC_q15_fast_nonsquare.c arm_convolve_HWC_q7_RGB.c arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_basic_nonsquare.c arm_convolve_HWC_q7_fast.c arm_convolve_HWC_q7_fast_nonsquare.c arm_convolve_fast_s16.c arm_convolve_s16.c arm_convolve_s8.c arm_convolve_wrapper_s16.c arm_convolve_wrapper_s8.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_fast_s16.c arm_depthwise_conv_s16.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_wrapper_s16.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_separable_conv_HWC_q7.c arm_depthwise_separable_conv_HWC_q7_nonsquare.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_q7_q15.c arm_nn_mat_mult_kernel_q7_q15_reordered.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s8_s16_reordered.c arm_nn_mat_mult_s8.c
    ../../../../../external/CMSIS/cmsis_NN/Source/FullyConnectedFunctions/: arm_fully_connected_mat_q7_vec_q15.c arm_fully_connected_mat_q7_vec_q15_opt.c arm_fully_connected_q15.c arm_fully_connected_q15_opt.c arm_fully_connected_q7.c arm_fully_connected_q7_opt.c arm_fully_connected_s16.c arm_fully_connected_s8.c
    ../../../../../external/CMSIS/cmsis_NN/Source/NNSupportFunctions/: arm_nn_accumulate_q7_to_q15.c arm_nn_add_q7.c arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mul_kernel_s16.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mult_q15.c arm_nn_mult_q7.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_no_shift.c arm_q7_to_q15_reordered_no_shift.c arm_q7_to_q15_reordered_with_offset.c arm_q7_to_q15_with_offset.c
    ../../../../../external/CMSIS/cmsis_NN/Source/PoolingFunctions/: arm_avgpool_s16.c arm_avgpool_s8.c arm_max_pool_s16.c arm_max_pool_s8.c arm_max_pool_s8_opt.c arm_pool_q7_HWC.c
    ../../../../../external/CMSIS/cmsis_NN/Source/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_q15.c arm_softmax_q7.c arm_softmax_s16.c arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_u8.c arm_softmax_with_batch_q7.c
    ../../../../../external/CMSIS/cmsis_NN/Source/NNTest/: arm_convolve_HWC_q15_ref.c arm_convolve_HWC_q15_ref_nonsquare.c arm_convolve_HWC_q7_ref.c arm_convolve_HWC_q7_ref_nonsquare.c arm_depthwise_separable_conv_HWC_q7_ref.c arm_depthwise_separable_conv_HWC_q7_ref_nonsquare.c arm_fully_connected_mat_q7_vec_q15_opt_ref.c arm_fully_connected_mat_q7_vec_q15_ref.c arm_fully_connected_q15_opt_ref.c arm_fully_connected_q15_ref.c arm_fully_connected_q7_opt_ref.c arm_fully_connected_q7_ref.c arm_nn_mult_ref.c arm_pool_ref.c arm_relu_ref.c
    ../../../../../external/CMSIS/cmsis_NN/Source/SVDFunctions/: arm_svdf_s8.c arm_svdf_state_s16_s8.c
  group FlashDB
    ../../../../../external/FlashDB/port/fal/src/: fal.c fal_flash.c fal_flash_sifli_port.c fal_partition.c fal_rtt.c
    ../../../../../external/FlashDB/src/: fdb.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
  group freetype
    ../../../../../external/freetype/lib_interface/: ftsystem.c
  group libhelix
    ../../../../../external/libhelix-mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
    ../../../../../external/libhelix-mp3/: mp3tabs.c mp3dec.c
  group LVGL
    ../../../../../external/lvgl_v8/src/core/: lv_disp.c lv_event.c lv_gesture.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../../../../external/lvgl_v8/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../../../../external/lvgl_v8/src/extra/: lv_extra.c
    ../../../../../external/lvgl_v8/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../../../../../external/lvgl_v8/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../../../../external/lvgl_v8/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../../../../external/lvgl_v8/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../../../../../external/lvgl_v8/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../../../../external/lvgl_v8/src/draw/nxp/: lv_gpu_nxp.c
    ../../../../../external/lvgl_v8/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../../../../external/lvgl_v8/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../../../../external/lvgl_v8/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../../../../external/lvgl_v8/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../../../../external/lvgl_v8/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../../../../external/lvgl_v8/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_rect.c lv_gpu_nxp_vglite.c
    ../../../../../external/lvgl_v8/src/extra/layouts/flex/: lv_flex.c
    ../../../../../external/lvgl_v8/src/extra/layouts/grid/: lv_grid.c
    ../../../../../external/lvgl_v8/src/extra/libs/bmp/: lv_bmp.c
    ../../../../../external/lvgl_v8/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../../../../external/lvgl_v8/src/extra/libs/freetype/: lv_freetype.c
    ../../../../../external/lvgl_v8/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../../../../external/lvgl_v8/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../../../../external/lvgl_v8/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../../../external/lvgl_v8/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../../../external/lvgl_v8/src/extra/libs/rlottie/: lv_rlottie.c
    ../../../../../external/lvgl_v8/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../../../external/lvgl_v8/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../../../../external/lvgl_v8/src/extra/others/gridnav/: lv_gridnav.c
    ../../../../../external/lvgl_v8/src/extra/others/ime/: lv_ime_pinyin.c
    ../../../../../external/lvgl_v8/src/extra/others/imgfont/: lv_imgfont.c
    ../../../../../external/lvgl_v8/src/extra/others/monkey/: lv_monkey.c
    ../../../../../external/lvgl_v8/src/extra/others/msg/: lv_msg.c
    ../../../../../external/lvgl_v8/src/extra/others/snapshot/: lv_snapshot.c
    ../../../../../external/lvgl_v8/src/extra/themes/basic/: lv_theme_basic.c
    ../../../../../external/lvgl_v8/src/extra/themes/default/: lv_theme_default.c
    ../../../../../external/lvgl_v8/src/extra/themes/mono/: lv_theme_mono.c
    ../../../../../external/lvgl_v8/src/extra/widgets/animimg/: lv_animimg.c
    ../../../../../external/lvgl_v8/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../../external/lvgl_v8/src/extra/widgets/chart/: lv_chart.c
    ../../../../../external/lvgl_v8/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../../../external/lvgl_v8/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../../../external/lvgl_v8/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../../../external/lvgl_v8/src/extra/widgets/led/: lv_led.c
    ../../../../../external/lvgl_v8/src/extra/widgets/list/: lv_list.c
    ../../../../../external/lvgl_v8/src/extra/widgets/menu/: lv_menu.c
    ../../../../../external/lvgl_v8/src/extra/widgets/meter/: lv_meter.c
    ../../../../../external/lvgl_v8/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../../../external/lvgl_v8/src/extra/widgets/span/: lv_span.c
    ../../../../../external/lvgl_v8/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../../../external/lvgl_v8/src/extra/widgets/spinner/: lv_spinner.c
    ../../../../../external/lvgl_v8/src/extra/widgets/tabview/: lv_tabview.c
    ../../../../../external/lvgl_v8/src/extra/widgets/tileview/: lv_tileview.c
    ../../../../../external/lvgl_v8/src/extra/widgets/win/: lv_win.c
  group lz4
    ../../../../../external/lz4/: lz4.c
  group libopus
    ../../../../../external/opus-1.4/celt/: bands.c celt.c celt_decoder.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c pitch.c quant_bands.c rate.c vq.c
    ../../../../../external/opus-1.4/silk/: A2NLSF.c CNG.c HP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c LP_variable_cutoff.c NLSF2A.c NLSF_VQ.c NLSF_VQ_weights_laroia.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_unpack.c NSQ.c NSQ_del_dec.c PLC.c VAD.c VQ_WMat_EC.c ana_filt_bank_1.c biquad_alt.c bwexpander.c bwexpander_32.c check_control_input.c code_signs.c control_SNR.c control_audio_bandwidth.c control_codec.c debug.c dec_API.c decode_core.c decode_frame.c decode_indices.c decode_parameters.c decode_pitch.c decode_pulses.c decoder_set_fs.c enc_API.c encode_indices.c encode_pulses.c gain_quant.c init_decoder.c init_encoder.c inner_prod_aligned.c interpolate.c lin2log.c log2lin.c pitch_est_tables.c process_NLSFs.c quant_LTP_gains.c resampler.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_IIR_FIR.c resampler_private_down_FIR.c resampler_private_up2_HQ.c resampler_rom.c shell_coder.c sigm_Q15.c sort.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_decode_pred.c stereo_encode_pred.c stereo_find_predictor.c stereo_quant_pred.c sum_sqr_shift.c table_LSF_cos.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_gain.c tables_other.c tables_pitch_lag.c tables_pulses_per_block.c
    ../../../../../external/opus-1.4/silk/fixed/: LTP_analysis_filter_FIX.c LTP_scale_ctrl_FIX.c apply_sine_window_FIX.c autocorr_FIX.c burg_modified_FIX.c corrMatrix_FIX.c encode_frame_FIX.c find_LPC_FIX.c find_LTP_FIX.c find_pitch_lags_FIX.c find_pred_coefs_FIX.c k2a_FIX.c k2a_Q16_FIX.c noise_shape_analysis_FIX.c pitch_analysis_core_FIX.c process_gains_FIX.c regularize_correlations_FIX.c residual_energy16_FIX.c residual_energy_FIX.c schur64_FIX.c schur_FIX.c vector_ops_FIX.c warped_autocorrelation_FIX.c
    ../../../../../external/opus-1.4/src/: analysis.c mapping_matrix.c mlp.c mlp_data.c opus.c opus_decoder.c opus_encoder.c opus_multistream.c opus_multistream_decoder.c opus_multistream_encoder.c opus_projection_decoder.c opus_projection_encoder.c opus_test.c repacketizer.c
  group state_machine
    ../../../../../external/state_machine-latest/src/: state_machine.c
  group RTduino-libraries
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/kernels/: kernel_util.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/micro/: all_ops_resolver.cpp debug_log.cpp fake_micro_context.cpp flatbuffer_utils.cpp memory_helpers.cpp micro_allocation_info.cpp micro_allocator.cpp micro_context.cpp micro_graph.cpp micro_interpreter.cpp micro_log.cpp micro_profiler.cpp micro_resource_variable.cpp micro_string.cpp micro_time.cpp micro_utils.cpp mock_micro_graph.cpp recording_micro_allocator.cpp system_setup.cpp test_helper_custom_ops.cpp test_helpers.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/schema/: schema_utils.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/core/api/: error_reporter.cpp flatbuffer_conversions.cpp op_resolver.cpp tensor_utils.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/core/c/: common.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/experimental/microfrontend/lib/: filterbank.c filterbank_util.c frontend.c frontend_util.c log_lut.c log_scale.c log_scale_util.c noise_reduction.c noise_reduction_util.c pcan_gain_control.c pcan_gain_control_util.c window.c window_util.c fft.cpp fft_util.cpp kiss_fft_int16.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/kernels/internal/: portable_tensor_utils.cpp quantization_util.cpp tensor_utils.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/kernels/internal/reference/: portable_tensor_utils.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/micro/arena_allocator/: non_persistent_arena_buffer_allocator.cpp persistent_arena_buffer_allocator.cpp recording_single_arena_buffer_allocator.cpp single_arena_buffer_allocator.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/micro/kernels/: activations.cpp activations_common.cpp add_common.cpp add_n.cpp arg_min_max.cpp assign_variable.cpp batch_matmul.cpp batch_matmul_common.cpp batch_to_space_nd.cpp broadcast_args.cpp broadcast_to.cpp call_once.cpp cast.cpp ceil.cpp circular_buffer.cpp circular_buffer_common.cpp comparisons.cpp concatenation.cpp conv_common.cpp cumsum.cpp depth_to_space.cpp depthwise_conv_common.cpp dequantize.cpp dequantize_common.cpp detection_postprocess.cpp div.cpp elementwise.cpp elu.cpp ethosu.cpp exp.cpp expand_dims.cpp fill.cpp floor.cpp floor_div.cpp floor_mod.cpp fully_connected_common.cpp gather.cpp gather_nd.cpp hard_swish.cpp hard_swish_common.cpp if.cpp kernel_runner.cpp kernel_util.cpp l2_pool_2d.cpp l2norm.cpp leaky_relu.cpp leaky_relu_common.cpp log_softmax.cpp logical.cpp logical_common.cpp logistic.cpp logistic_common.cpp lstm_eval.cpp maximum_minimum.cpp micro_tensor_utils.cpp mirror_pad.cpp mul_common.cpp neg.cpp pack.cpp pad.cpp pooling_common.cpp prelu.cpp prelu_common.cpp quantize.cpp quantize_common.cpp read_variable.cpp reduce.cpp reduce_common.cpp reshape.cpp resize_bilinear.cpp resize_nearest_neighbor.cpp round.cpp select.cpp shape.cpp slice.cpp softmax_common.cpp space_to_batch_nd.cpp space_to_depth.cpp split.cpp split_v.cpp squared_difference.cpp squeeze.cpp strided_slice.cpp sub.cpp sub_common.cpp svdf_common.cpp tanh.cpp transpose.cpp transpose_conv.cpp unidirectional_sequence_lstm.cpp unpack.cpp var_handle.cpp while.cpp zeros_like.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cpp linear_memory_planner.cpp non_persistent_buffer_planner_shim.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.cpp micro_error_reporter.cpp op_resolver_bridge.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/tensorflow/lite/micro/kernels/cmsis_nn/: add.cpp conv.cpp depthwise_conv.cpp fully_connected.cpp mul.cpp pooling.cpp softmax.cpp svdf.cpp
    ../../../../../external/TensorFlow-Lite-Micro/src/third_party/kissfft/: kiss_fft.c
    ../../../../../external/TensorFlow-Lite-Micro/src/third_party/kissfft/tools/: kiss_fftr.c
  group webrtc
    ../../../../../external/WebRTC_audio_processing/webrtc/common_audio/: fft4g.c ring_buffer.c
    ../../../../../external/WebRTC_audio_processing/webrtc/common_audio/vad/: signal_processing_library.c vad_core.c vad_filterbank.c vad_gmm.c vad_sp.c webrtc_vad.c
    ../../../../../external/WebRTC_audio_processing/webrtc/common_audio/signal_processing/: auto_corr_to_refl_coef.c auto_correlation.c complex_bit_reverse.c complex_fft.c copy_set_operations.c cross_correlation.c division_operations.c dot_product_with_scale.c downsample_fast.c energy.c filter_ar.c filter_ar_fast_q12.c filter_ma_fast_q12.c get_hanning_window.c get_scaling_square.c ilbc_specific_functions.c levinson_durbin.c lpc_to_refl_coef.c min_max_operations.c randomization_functions.c real_fft.c refl_coef_to_lpc.c resample.c resample_48khz.c resample_by_2.c resample_by_2_internal.c resample_fractional.c spl_init.c spl_sqrt.c spl_sqrt_floor.c splitting_filter.c sqrt_of_one_minus_x_squared.c vector_scaling_operations.c
    ../../../../../external/WebRTC_audio_processing/webrtc/modules/audio_processing/ns/: noise_suppression_x.c nsx_core.c nsx_core_c.c
    ../../../../../external/WebRTC_audio_processing/webrtc/modules/audio_processing/agc/legacy/: analog_agc.c digital_agc.c
    ../../../../../external/WebRTC_audio_processing/webrtc/modules/audio_processing/aecm/: aecm_core.c aecm_core_c.c echo_control_mobile.c
    ../../../../../external/WebRTC_audio_processing/webrtc/modules/audio_processing/utility/: delay_estimator.c delay_estimator_wrapper.c
    ../../../../../external/WebRTC_audio_processing/webrtc/modules/audio_processing/dc_correction/: dc_correction.c
    ../../../../../external/WebRTC_audio_processing/webrtc/modules/audio_processing/ramp_in/: ramp_in.c
    ../../../../../external/WebRTC_audio_processing/webrtc/modules/audio_processing/ramp_out/: ramp_out.c
    ../../../../../external/WebRTC_audio_processing/: webrtc_vad_test.c
  group middleware
    ../../../../../middleware/button/: button.c
    ../../../../../middleware/context_backup/: context_backup.c
    ../../../../../middleware/cpu_usage_profiler/: cpu_usage_profiler.c
    ../../../../../middleware/ezipa_dec/: ezipa_dec.c
    ../../../../../middleware/ipc_queue/common/: circular_buf.c ipc_hw.c ipc_queue.c
    ../../../../../middleware/ipc_queue/porting/sf32lb56x/hcpu/: ipc_hw_port.c
  group app_fwk
    ../../../../../middleware/app_fwk/: app_schedule.c app_schedule_port.c gui_app_fwk.c gui_app_test.c gui_app_trans_anim.c gui_dl_app_fwk.c intent.c
    ../../../../../middleware/app_fwk/reg_fwk/: app_reg.c
    ../../../../../middleware/app_fwk/lvgl_v8/: app_trans_anim_port.c
  group audio
    ../../../../../middleware/audio/audio_bt_voice/: audio_bt_voice.c audio_cvsd.c audio_filter.c audio_msbc_plc.c bt_audiopath.c
    ../../../../../middleware/audio/audio_local_music/: audio_loopback_demo.c audio_mp3ctrl.c mp3id3parse.c sifli_resample.c
    ../../../../../middleware/audio/audio_manager/: audio_server.c audio_test_demo.c
    ../../../../../middleware/audio/audio_port/: audio_eq_config.c audio_mem.c audio_pa_api.c
    ../../../../../middleware/audio/audio_voice_proc/: audio_3a.c
  group lib_barcode128
    ../../../../../middleware/barcode128/: barcode128_rvds.lib
  group rw_rtt
    ../../../../../middleware/bluetooth/porting/rtt/: rw_rtt.c
  group bt
    ../../../../../middleware/bluetooth/service/: bluetooth.c
    ../../../../../middleware/bluetooth/service/ble/: bf0_ble_gap.c bf0_sibles.c bf0_sibles_advertising.c bf0_sibles_advertising_internal.c bf0_sibles_util.c ble_connection_manager.c
    ../../../../../middleware/bluetooth/service/ble/gatt_service/: bf0_ble_basc.c bf0_ble_cppc.c bf0_ble_cscpc.c bf0_ble_hrpc.c bf0_ble_tipc.c bf0_ble_tips.c bf0_sible_ams.c bf0_sibles_ancs.c bf0_sibles_bass.c bf0_sibles_console.c bf0_sibles_dfu.c bf0_sibles_diss.c bf0_sibles_eq_config.c bf0_sibles_fmpt.c bf0_sibles_ias.c bf0_sibles_log.c bf0_sibles_pxpr.c bf0_sibles_serial_trans_client.c bf0_sibles_serial_trans_service.c bf0_sibles_tpss.c bf0_sibles_watchface.c
    ../../../../../middleware/bluetooth/service/bt/bt_audio/: a2dp_relay_sink_service.c a2dp_relay_src_service.c hfp_audio_api.c
    ../../../../../middleware/bluetooth/service/bt/bt_cm/: bt_connection_manager.c bt_connection_service.c
    ../../../../../middleware/bluetooth/service/bt/bt_finsh/: bts2_app_av.c bts2_app_av_snk.c bts2_app_av_src.c bts2_app_avrcp.c bts2_app_bt_dis.c bts2_app_bt_gatt.c bts2_app_bt_l2cap_profile.c bts2_app_cardparser.c bts2_app_demo.c bts2_app_generic.c bts2_app_hfp_ag.c bts2_app_hfp_hf.c bts2_app_hid.c bts2_app_interface.c bts2_app_main.c bts2_app_menu.c bts2_app_pan.c bts2_app_pbap_c.c bts2_app_spp.c bts2_app_sys.c
    ../../../../../middleware/bluetooth/service/common/: bf0_bt_common.c bf0_bt_hci.c bf0_bt_metrics.c bf0_bt_nvds.c bluetooth_hci_flash.c
    ../../../../../middleware/bluetooth/service/internal/: bluetooth_config.c bluetooth_misc.c
  group sifli_bt
    ../../../../../middleware/bluetooth/lib/: dummy.c
  group sifli_bt
    ../../../../../middleware/bluetooth/lib/: lib_bt_rvds.lib
  group data_bus
    ../../../../../middleware/data_bus/public/: data_service_main.c data_service.c pin_service.c power_manager_service.c ui_datasrv_subscriber.c ancs_service.c
  group lvgl_sifli
    ../../../../../middleware/lvgl/: littlevgl2rtt.c lvsf_perf.c lvsf_perf_v9.c app_mem.c
  group lv_ext_resouce
    ../../../../../middleware/lvgl/lv_ext_resouce/: app_comm.c app_lang.c app_nvm_lang_compat.c lv_ext_resource_manager.c lv_ext_resource_manager_builtin.c lv_ext_resource_manager_dl_impl.c
  group LV_SF
    ../../../../../middleware/lvgl/lvsf/: lv_ex_data.c lv_freetype.c lvsf_analogclk.c lvsf_barcode.c lvsf_comp.c lvsf_composite.c lvsf_corner.c lvsf_curvetext.c lvsf_emoji.c lvsf_ezipa.c lvsf_font.c lvsf_gesture.c lvsf_header.c lvsf_idximg.c lvsf_input.c lvsf_popup.c lvsf_rlottie.c lvsf_theme_1.c lvsf_utils.c
  group gui_widgets
    ../../../../../middleware/lvgl/lvsf/gui_widgets/: gui_widgets_rvds.lib
  group lv_drivers
    ../../../../../middleware/lvgl/lv_drivers/: lv_gpu_new_api.c lv_keypad.c lv_lcd.c lv_touch.c lv_wheel.c lvgl_drv.c lvsf_img_decoder.c
  group lib_lvgl_extensions
    ../../../../../middleware/lvgl/lvgl_extensions/: lvgl_extensions_rvds.lib
  group lib_gif_dec
    ../../../../../middleware/lvgl/gif_dec/: gif_dec_rvds.lib
  group share_prefs
    ../../../../../middleware/share_prefs/: share_prefs_cmd.c share_prefs_flashdb.c
  group sifli_lib
    ../../../../../middleware/sifli_lib/lib/: agif.c dummy.c
  group sifli_lib
    ../../../../../middleware/sifli_lib/lib/: Tiny_font_rvds.lib
  group m_system
    ../../../../../middleware/system/: bf0_common.c bf0_pm.c gui_app_pm.c
  group os_adapter
    ../../../../../rtos/os_adaptor/src/: os_adaptor_rtthread.c
  group resource
    build_sf32lb56w-watch_hcpu/src/resource/images/common/no_ezip/: baro_arrow.tmp.c clock_dial_point_h.tmp.c clock_dial_point_m.tmp.c clock_dial_point_s.tmp.c clock_mickey_hand_hour.tmp.c clock_mickey_hand_minute.tmp.c clock_rotate_bg_bg.tmp.c clock_rotate_bg_bg_small.tmp.c clock_rotate_bg_bg_tiny.tmp.c clock_rotate_bg_hour_hand.tmp.c clock_rotate_bg_minute_hand.tmp.c clock_simple_hour_hand.tmp.c clock_simple_minute_hand.tmp.c clock_simple_second_hand.tmp.c compass_arrow.tmp.c d3d_rotate.tmp.c fashion_hr.tmp.c fashion_min.tmp.c fashion_sec.tmp.c hour_hand2.tmp.c kaleidoscope.tmp.c minute_hand2.tmp.c second_hand2.tmp.c
    build_sf32lb56w-watch_hcpu/src/resource/images/common/ezip/: Map_fill.tmp.c airplane.tmp.c app_elc_100.tmp.c app_elc_20.tmp.c app_elc_40.tmp.c app_elc_5.tmp.c app_elc_60.tmp.c app_elc_80.tmp.c app_icon_frame.tmp.c backspace_icon.tmp.c bg_loading.tmp.c btn_flashlight.tmp.c calculator_icon.tmp.c capital_icon.tmp.c charge_icon.tmp.c clock_40.tmp.c close_garage.tmp.c control_background_img.tmp.c control_cursor_img.tmp.c control_selection_bg.tmp.c dn.tmp.c down_arrow.tmp.c enter_icon.tmp.c erth.tmp.c find_phone.tmp.c flashlight_icon.tmp.c header_bg.tmp.c icon_apple_facetime.tmp.c icon_apple_mail.tmp.c icon_bluetooth_disconnection.tmp.c icon_delete.tmp.c icon_dingtalk.tmp.c icon_discord.tmp.c icon_dnd_mode.tmp.c icon_facebook.tmp.c icon_gmail.tmp.c icon_google_calendar.tmp.c icon_google_chat.tmp.c icon_google_meet.tmp.c icon_history.tmp.c icon_instagram.tmp.c icon_kakaotalk.tmp.c icon_lark.tmp.c icon_line.tmp.c icon_linkedin.tmp.c icon_messenger.tmp.c icon_mic.tmp.c icon_other.tmp.c icon_prohibit.tmp.c icon_qq.tmp.c icon_qrcode.tmp.c icon_record.tmp.c icon_reddit.tmp.c icon_release.tmp.c icon_send.tmp.c icon_skaiwalk.tmp.c icon_skype.tmp.c icon_slack.tmp.c icon_sleep_mode.tmp.c icon_sms.tmp.c icon_snap.tmp.c icon_stop.tmp.c icon_telegram.tmp.c icon_tiktok.tmp.c icon_trash.tmp.c icon_twitch.tmp.c icon_twitter.tmp.c icon_wechat.tmp.c icon_whatsapp.tmp.c icon_x.tmp.c icon_youtube.tmp.c img_activity.tmp.c img_alarm.tmp.c img_alarm_2.tmp.c img_barometer.tmp.c img_calculator.tmp.c img_calendar.tmp.c img_calories.tmp.c img_charging.tmp.c img_dinosaur.tmp.c img_enemy.tmp.c img_flashlight.tmp.c img_game.tmp.c img_group.tmp.c img_heart_rate.tmp.c img_itunes.tmp.c img_left_arrow.tmp.c img_logo.tmp.c img_low_power.tmp.c img_mail.tmp.c img_media_next.tmp.c img_media_pause.tmp.c img_media_play.tmp.c img_media_previous.tmp.c img_messages.tmp.c img_mouse.tmp.c img_note.tmp.c img_photo.tmp.c img_recorder.tmp.c img_red_heart.tmp.c img_settings.tmp.c img_settings_app.tmp.c img_workout.tmp.c img_workout_cycling.tmp.c img_workout_gym.tmp.c img_workout_hiking.tmp.c img_workout_running.tmp.c img_workout_swimming.tmp.c img_workout_walking.tmp.c img_workout_yoga.tmp.c language.tmp.c menu_icon.tmp.c micro_icon.tmp.c mouse_mode_icon.tmp.c next_arrow.tmp.c notification_img.tmp.c open_garage.tmp.c phone_call.tmp.c plus.tmp.c plus_button.tmp.c previous_arrow.tmp.c service_hour.tmp.c skaiwalkicon.tmp.c small_img_logo.tmp.c small_img_logo_matting.tmp.c space.tmp.c sun.tmp.c switch_icon.tmp.c tap_bg_left.tmp.c tap_bg_right.tmp.c unknown_bg_left.tmp.c unknown_bg_right.tmp.c up_arrow.tmp.c voice_group.tmp.c volume_down.tmp.c volume_up.tmp.c weather_clear.tmp.c weather_cloudy.tmp.c weather_rain.tmp.c weather_sun.tmp.c weather_thunder.tmp.c weather_widget_bg.tmp.c
    build_sf32lb56w-watch_hcpu/src/resource/images/common/large_ezip/: device_btn.tmp.c dig_1_00.tmp.c dig_1_01.tmp.c dig_1_02.tmp.c dig_1_03.tmp.c dig_1_04.tmp.c dig_1_05.tmp.c dig_1_06.tmp.c dig_1_07.tmp.c dig_1_08.tmp.c dig_1_09.tmp.c gaus_clock1_bg.tmp.c gaus_clock4_bg.tmp.c gaus_default_picture.tmp.c img_earth_digital_bg.tmp.c media_gaus_bg.tmp.c message_widget_bg.tmp.c
    ../../src/hcpu/resource/fonts/freetype/: font_partition_dsc.c
    build_sf32lb56w-watch_hcpu/src/resource/strings/: en_us.c zh_cn.c lang_pack.c
  group App_watch_demo
    ../../src/hcpu/gui_apps/: watch_demo.c
    ../../src/hcpu/gui_apps/alarm/: app_alarm.c app_alarm_edit.c app_alarm_edit_repeat.c app_alarm_edit_time.c
    ../../src/hcpu/gui_apps/app_layout/: lv_app_list_layout.c lv_instruction_list_layout.c lv_message_list_layout.c lv_simplified_obj.c
    ../../src/hcpu/gui_apps/battery/: app_battery.c
    ../../src/hcpu/gui_apps/calculator/: app_calculator.c
    ../../src/hcpu/gui_apps/camera/: app_camera.c
    ../../src/hcpu/gui_apps/clock/: app_clock_earth_digita.c app_clock_main.c app_clock_status_bar.c
    ../../src/hcpu/gui_apps/common/: arc_scroll.c common_bg.c common_button.c common_icon.c ui_helper.c
    ../../src/hcpu/gui_apps/exercise/: app_exercise.c
    ../../src/hcpu/gui_apps/file_browser/: app_file_browser.c
    ../../src/hcpu/gui_apps/flashlight/: app_flashlight.c rgb_control_panel.c
    ../../src/hcpu/gui_apps/game/: app_game_dinosaur.c
    ../../src/hcpu/gui_apps/gesture/: app_gesture.c
    ../../src/hcpu/gui_apps/hid_mouse/: hid_mouse.c
    ../../src/hcpu/gui_apps/interact/: app_interact.c app_system_interface.c
    ../../src/hcpu/gui_apps/loader/: app_loader.c skaiwalk_demo.c
    ../../src/hcpu/gui_apps/main/: app_mainmenu.c
    ../../src/hcpu/gui_apps/media/: app_media.c
    ../../src/hcpu/gui_apps/message/: app_message.c app_message_database.c
    ../../src/hcpu/gui_apps/photo/: app_photo.c
    ../../src/hcpu/gui_apps/qrcode/: app_qrcode.c
    ../../src/hcpu/gui_apps/recorder/: app_recorder.c
    ../../src/hcpu/gui_apps/setting/: app_developer.c app_setting.c app_setting_device_list.c app_setting_display.c app_setting_sys_info.c
    ../../src/hcpu/gui_apps/skai/: app_skai.c
    ../../src/hcpu/gui_apps/speech/: app_speech.c app_speech_provider.c
    ../../src/hcpu/gui_apps/test/: app_test.c test_gif_bulb.c
    ../../src/hcpu/gui_apps/timer/: app_timer.c
    ../../src/hcpu/gui_apps/utils/: custom_trans_anim.c
    ../../src/hcpu/gui_apps/weather/: app_weather.c
  group App_incoming_call
    ../../src/hcpu/gui_apps/incoming_call/: app_incoming_call.c
  group App_onboarding
    ../../src/hcpu/gui_apps/onboarding/: app_onboarding.c
  group app
    ../../src/hcpu/: log_file_backend.c main.c
    build_sf32lb56w-watch_hcpu/src/resource/images/common/no_ezip/: baro_arrow.tmp.c clock_dial_point_h.tmp.c clock_dial_point_m.tmp.c clock_dial_point_s.tmp.c clock_mickey_hand_hour.tmp.c clock_mickey_hand_minute.tmp.c clock_rotate_bg_bg.tmp.c clock_rotate_bg_bg_small.tmp.c clock_rotate_bg_bg_tiny.tmp.c clock_rotate_bg_hour_hand.tmp.c clock_rotate_bg_minute_hand.tmp.c clock_simple_hour_hand.tmp.c clock_simple_minute_hand.tmp.c clock_simple_second_hand.tmp.c compass_arrow.tmp.c d3d_rotate.tmp.c fashion_hr.tmp.c fashion_min.tmp.c fashion_sec.tmp.c hour_hand2.tmp.c kaleidoscope.tmp.c minute_hand2.tmp.c second_hand2.tmp.c
    build_sf32lb56w-watch_hcpu/src/resource/images/common/ezip/: Map_fill.tmp.c airplane.tmp.c app_elc_100.tmp.c app_elc_20.tmp.c app_elc_40.tmp.c app_elc_5.tmp.c app_elc_60.tmp.c app_elc_80.tmp.c app_icon_frame.tmp.c backspace_icon.tmp.c bg_loading.tmp.c btn_flashlight.tmp.c calculator_icon.tmp.c capital_icon.tmp.c charge_icon.tmp.c clock_40.tmp.c close_garage.tmp.c control_background_img.tmp.c control_cursor_img.tmp.c control_selection_bg.tmp.c dn.tmp.c down_arrow.tmp.c enter_icon.tmp.c erth.tmp.c find_phone.tmp.c flashlight_icon.tmp.c header_bg.tmp.c icon_apple_facetime.tmp.c icon_apple_mail.tmp.c icon_bluetooth_disconnection.tmp.c icon_delete.tmp.c icon_dingtalk.tmp.c icon_discord.tmp.c icon_dnd_mode.tmp.c icon_facebook.tmp.c icon_gmail.tmp.c icon_google_calendar.tmp.c icon_google_chat.tmp.c icon_google_meet.tmp.c icon_history.tmp.c icon_instagram.tmp.c icon_kakaotalk.tmp.c icon_lark.tmp.c icon_line.tmp.c icon_linkedin.tmp.c icon_messenger.tmp.c icon_mic.tmp.c icon_other.tmp.c icon_prohibit.tmp.c icon_qq.tmp.c icon_qrcode.tmp.c icon_record.tmp.c icon_reddit.tmp.c icon_release.tmp.c icon_send.tmp.c icon_skaiwalk.tmp.c icon_skype.tmp.c icon_slack.tmp.c icon_sleep_mode.tmp.c icon_sms.tmp.c icon_snap.tmp.c icon_stop.tmp.c icon_telegram.tmp.c icon_tiktok.tmp.c icon_trash.tmp.c icon_twitch.tmp.c icon_twitter.tmp.c icon_wechat.tmp.c icon_whatsapp.tmp.c icon_x.tmp.c icon_youtube.tmp.c img_activity.tmp.c img_alarm.tmp.c img_alarm_2.tmp.c img_barometer.tmp.c img_calculator.tmp.c img_calendar.tmp.c img_calories.tmp.c img_charging.tmp.c img_dinosaur.tmp.c img_enemy.tmp.c img_flashlight.tmp.c img_game.tmp.c img_group.tmp.c img_heart_rate.tmp.c img_itunes.tmp.c img_left_arrow.tmp.c img_logo.tmp.c img_low_power.tmp.c img_mail.tmp.c img_media_next.tmp.c img_media_pause.tmp.c img_media_play.tmp.c img_media_previous.tmp.c img_messages.tmp.c img_mouse.tmp.c img_note.tmp.c img_photo.tmp.c img_recorder.tmp.c img_red_heart.tmp.c img_settings.tmp.c img_settings_app.tmp.c img_workout.tmp.c img_workout_cycling.tmp.c img_workout_gym.tmp.c img_workout_hiking.tmp.c img_workout_running.tmp.c img_workout_swimming.tmp.c img_workout_walking.tmp.c img_workout_yoga.tmp.c language.tmp.c menu_icon.tmp.c micro_icon.tmp.c mouse_mode_icon.tmp.c next_arrow.tmp.c notification_img.tmp.c open_garage.tmp.c phone_call.tmp.c plus.tmp.c plus_button.tmp.c previous_arrow.tmp.c service_hour.tmp.c skaiwalkicon.tmp.c small_img_logo.tmp.c small_img_logo_matting.tmp.c space.tmp.c sun.tmp.c switch_icon.tmp.c tap_bg_left.tmp.c tap_bg_right.tmp.c unknown_bg_left.tmp.c unknown_bg_right.tmp.c up_arrow.tmp.c voice_group.tmp.c volume_down.tmp.c volume_up.tmp.c weather_clear.tmp.c weather_cloudy.tmp.c weather_rain.tmp.c weather_sun.tmp.c weather_thunder.tmp.c weather_widget_bg.tmp.c
    build_sf32lb56w-watch_hcpu/src/resource/images/common/large_ezip/: device_btn.tmp.c dig_1_00.tmp.c dig_1_01.tmp.c dig_1_02.tmp.c dig_1_03.tmp.c dig_1_04.tmp.c dig_1_05.tmp.c dig_1_06.tmp.c dig_1_07.tmp.c dig_1_08.tmp.c dig_1_09.tmp.c gaus_clock1_bg.tmp.c gaus_clock4_bg.tmp.c gaus_default_picture.tmp.c img_earth_digital_bg.tmp.c media_gaus_bg.tmp.c message_widget_bg.tmp.c
    ../../src/hcpu/resource/fonts/freetype/: font_partition_dsc.c
    build_sf32lb56w-watch_hcpu/src/resource/strings/: en_us.c zh_cn.c lang_pack.c
    ../../src/hcpu/gui_apps/: watch_demo.c
    ../../src/hcpu/gui_apps/alarm/: app_alarm.c app_alarm_edit.c app_alarm_edit_repeat.c app_alarm_edit_time.c
    ../../src/hcpu/gui_apps/app_layout/: lv_app_list_layout.c lv_instruction_list_layout.c lv_message_list_layout.c lv_simplified_obj.c
    ../../src/hcpu/gui_apps/battery/: app_battery.c
    ../../src/hcpu/gui_apps/calculator/: app_calculator.c
    ../../src/hcpu/gui_apps/camera/: app_camera.c
    ../../src/hcpu/gui_apps/clock/: app_clock_earth_digita.c app_clock_main.c app_clock_status_bar.c
    ../../src/hcpu/gui_apps/common/: arc_scroll.c common_bg.c common_button.c common_icon.c ui_helper.c
    ../../src/hcpu/gui_apps/exercise/: app_exercise.c
    ../../src/hcpu/gui_apps/file_browser/: app_file_browser.c
    ../../src/hcpu/gui_apps/flashlight/: app_flashlight.c rgb_control_panel.c
    ../../src/hcpu/gui_apps/game/: app_game_dinosaur.c
    ../../src/hcpu/gui_apps/gesture/: app_gesture.c
    ../../src/hcpu/gui_apps/hid_mouse/: hid_mouse.c
    ../../src/hcpu/gui_apps/incoming_call/: app_incoming_call.c
    ../../src/hcpu/gui_apps/interact/: app_interact.c app_system_interface.c
    ../../src/hcpu/gui_apps/loader/: app_loader.c skaiwalk_demo.c
    ../../src/hcpu/gui_apps/main/: app_mainmenu.c
    ../../src/hcpu/gui_apps/media/: app_media.c
    ../../src/hcpu/gui_apps/message/: app_message.c app_message_database.c
    ../../src/hcpu/gui_apps/onboarding/: app_onboarding.c
    ../../src/hcpu/gui_apps/photo/: app_photo.c
    ../../src/hcpu/gui_apps/qrcode/: app_qrcode.c
    ../../src/hcpu/gui_apps/recorder/: app_recorder.c
    ../../src/hcpu/gui_apps/setting/: app_developer.c app_setting.c app_setting_device_list.c app_setting_display.c app_setting_sys_info.c
    ../../src/hcpu/gui_apps/skai/: app_skai.c
    ../../src/hcpu/gui_apps/speech/: app_speech.c app_speech_provider.c
    ../../src/hcpu/gui_apps/test/: app_test.c test_gif_bulb.c
    ../../src/hcpu/gui_apps/timer/: app_timer.c
    ../../src/hcpu/gui_apps/utils/: custom_trans_anim.c
    ../../src/hcpu/gui_apps/weather/: app_weather.c
  group Algorithm
    ../../src/modules/algorithm/AirMouse/: air_mouse.c
  group GestureRecognition
    ../../src/modules/algorithm/GestureRecognition/: accelerometer_handler.cc gesture_detect_model_data.cc gesture_detect_test.cc gesture_predictor.cc grab_micro_features_data.cc main_functions.cc unknown_micro_features_data.cc gesture_model_loader.c gesture_recognition_task.c
  group Bloc
    ../../src/modules/bloc/: bloc_control.c bloc_flash.c bloc_calendar.c bloc_notification.c bloc_setting.c bloc_skaiwalk.c bloc_v2t.c bloc_peripheral.c bloc_weather.c bloc_motion_tracking.c bloc_filesystem.c bloc_system_perception.c bloc_exercise.c
  group Client
    ../../src/modules/client/: imu_client.c hr_client.c watch_system_client.c alarm_client.c
  group Communicate
    ../../src/modules/communicate/: communicate_protocol.c communicate_task.c communicate_parse.c communicate_parse_bond.c communicate_parse_control.c communicate_parse_health.c communicate_parse_notify.c communicate_parse_setting.c communicate_update_image.c wristband_ble_log.c
  group Model
    ../../src/modules/model/: watch_global_data.c watch_system_interact.c ui_handler.c gesture_handler.c touch_state_manager.c audio_code_i2s.c ble_device_manager.c ble_hid.c ble_ulog_backend.c
  group Service
    ../../src/modules/service/: alarm_manager_service.c
  group Utils
    ../../src/modules/util/: trig.c list.c math_fixed.c platform.c
    ../../src/modules/util/includes/util/time/: time.c
  group child_proj
    build_sf32lb56w-watch_hcpu/lcpu/: lcpu.c
  group CORTEX-M33
    ../../../../../rtos/rtthread/libcpu/arm/cortex-m33/: cpuport.c context_rvds.S
    ../../../../../rtos/rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group CPlusPlus
    ../../../../../rtos/rtthread/components/cplusplus/: cxx_crt.cpp cxx_mutex.cpp cxx_semaphore.cpp cxx_thread.cpp cxx_crt_init.c
  group Filesystem
    ../../../../../rtos/rtthread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../../../rtos/rtthread/components/dfs/filesystems/devfs/: devfs.c
    ../../../../../rtos/rtthread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
  group dhara
    ../../../../../rtos/rtthread/components/dfs/filesystems/dhara/dhara/: error.c journal.c map.c nand.c
  group DeviceDrivers
    ../../../../../rtos/rtthread/components/drivers/audio/: audio.c audio_pipe.c
    ../../../../../rtos/rtthread/components/drivers/hwmailbox/: hwmailbox.c
    ../../../../../rtos/rtthread/components/drivers/hwtimer/: hwtimer.c
    ../../../../../rtos/rtthread/components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../../../../rtos/rtthread/components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../../../rtos/rtthread/components/drivers/mtd/: mtd_nand.c
    ../../../../../rtos/rtthread/components/drivers/pm/: pm.c
    ../../../../../rtos/rtthread/components/drivers/rtc/: rtc.c alarm.c
    ../../../../../rtos/rtthread/components/drivers/serial/: serial.c
    ../../../../../rtos/rtthread/components/drivers/spi/: spi_core.c spi_dev.c
    ../../../../../rtos/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../rtos/rtthread/components/drivers/watchdog/: watchdog.c
  group Sensors
    ../../../../../rtos/rtthread/components/drivers/sensors/: sensor.c
  group finsh
    ../../../../../rtos/rtthread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../../../rtos/rtthread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../../../../rtos/rtthread/components/libc/compilers/common/: gmtime_r.c unistd.c
  group Utilities
    ../../../../../rtos/rtthread/components/utilities/llt_mem/: llt_mem.c
    ../../../../../rtos/rtthread/components/utilities/ulog/: ulog.c
    ../../../../../rtos/rtthread/components/utilities/ulog/backend/: console_be.c
