# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: main
  AfterMake: postbuild.bat !L
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: ARM_MATH_LOOPUNROLL, SOC_BF0_LCPU, SIFLI_VERSION=33816576, LCPU_CONFIG_V1, USE_HAL_DRIVER, SIFLI_BUILD="1e27e0ad", HAL_TICK_PER_SECOND=1000, RT_USING_ARM_LIBC, SF32LB56X, __FILE__=__FILE_NAME__, ROM_ENABLED
  c misc: -Wno-builtin-macro-redefined
  c include: build_sf32lb56w-watch_lcpu;..\..\..\..\..\rtos\rtthread\include;..\..\src\lcpu;..\..\src\modules\algorithm\activity;..\..\src\modules\algorithm\activity\kraepelin;..\..\src\modules\algorithm\GestureDetect;..\..\src\modules\algorithm\HandTracking;..\..\src\modules\algorithm\MahonyAHRS;..\..\src\modules\bloc;..\..\src\modules\communicate;..\..\src\modules\model;..\..\src\modules\service;..\..\src\modules\tests;..\..\src\modules\util\includes;..\..\..\..\..\customer\boards\common;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\include\config\sf32lb56x;..\..\..\..\..\customer\boards\eh-lb563;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\eh-lb56xu;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\sf32lb56-watch;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\eh-lb56xu;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\sf32lb56w-watch;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\boards\eh-lb56xu;..\..\..\..\..\customer\boards\include;..\..\..\..\..\customer\peripherals\motor;..\..\..\..\..\customer\peripherals\common;..\..\..\..\..\customer\peripherals\rgb;..\..\..\..\..\customer\peripherals\sensor\BMI270-Sensor-API;..\..\..\..\..\customer\peripherals\sensor\BMI270-Sensor-API\common;..\..\..\..\..\customer\peripherals\sensor\gh3018;..\..\..\..\..\customer\peripherals\sensor\gh30x_algo\Basic\inc;..\..\..\..\..\customer\peripherals\sensor\gh30x_algo\Basic\lib;..\..\..\..\..\customer\peripherals\sensor\gh30x_algo\Basic\src;..\..\..\..\..\customer\peripherals\sensor\gh30x_algo_demo\call\inc;..\..\..\..\..\customer\peripherals\sensor\gh30x_algo_demo\call\src;..\..\..\..\..\customer\peripherals\sensor\gh30x_algo_demo\common\inc;..\..\..\..\..\customer\peripherals\sensor\gh30x_algo_demo\common\src;..\..\..\..\..\customer\peripherals\sensor\SPL06;..\..\..\..\..\rtos\rtthread\bsp\sifli\drivers;..\..\..\..\..\drivers\cmsis\sf32lb56x;..\..\..\..\..\drivers\cmsis\Include;..\..\..\..\..\external\CMSIS\Include;..\..\..\..\..\drivers\Include;..\..\..\..\..\drivers\hal_epic_ex;..\..\..\..\..\external\helper_worker;..\..\..\..\..\external\Kraepelin\kraepelin_algorithm;..\..\..\..\..\external\Kraepelin\kraepelin_reference;..\..\..\..\..\middleware\include;..\..\..\..\..\middleware\button;..\..\..\..\..\middleware\ipc_queue\common;..\..\..\..\..\middleware\ipc_queue\include;..\..\..\..\..\middleware\ipc_queue\porting\os;..\..\..\..\..\middleware\ipc_queue\porting\os\rtthread;..\..\..\..\..\middleware\ipc_queue\porting\sf32lb56x;..\..\..\..\..\middleware\ipc_queue\porting\sf32lb56x\lcpu;..\..\..\..\..\middleware\audio;..\..\..\..\..\middleware\audio\include;..\..\..\..\..\middleware\audio\audio_bt_voice;..\..\..\..\..\middleware\audio\audio_port;..\..\..\..\..\middleware\audio\audio_speaker_mic;..\..\..\..\..\middleware\audio\audio_voice_proc;..\..\..\..\..\middleware\bluetooth\service;..\..\..\..\..\middleware\bluetooth\service\internal;..\..\..\..\..\middleware\bluetooth\include;..\..\..\..\..\middleware\data_bus\public;..\..\..\..\..\middleware\data_bus\include;..\..\..\..\..\rtos\rtthread\components\drivers\sensors;..\..\..\..\..\middleware\sifli_lib\lib;..\..\..\..\..\middleware\include;..\..\..\..\..\rtos\os_adaptor\src;..\..\..\..\..\rtos\os_adaptor\inc;..\..\..\..\..\rtos\rtthread\libcpu\arm\cortex-m33;..\..\..\..\..\rtos\rtthread\libcpu\arm\common;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\motor;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\drivers\sensors;..\..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\..\rtos\rtthread\components\finsh;..\..\..\..\..\rtos\rtthread\components\libc\compilers\armlibc;..\..\..\..\..\rtos\rtthread\components\libc\compilers\common\include;..\..\..\..\..\rtos\rtthread\components\utilities\llt_mem;..\..\..\..\..\rtos\rtthread\components\utilities\ulog;..\..\..\..\..\rtos\rtthread\components\utilities\ulog\backend
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: build_sf32lb56w-watch_lcpu/link.sct
  link misc: --cpu=cortex-m33 --strict --scatter build_sf32lb56w-watch_lcpu/link.sct --summary_stderr --info summarysizes --map --load_addr_map_info --xref --callgraph --symbols --info sizes --info totals --info unused --info veneers --any_contingency  --list build_sf32lb56w-watch_lcpu/main.map  --symdefs=build_sf32lb56w-watch_lcpu/main.symdefs  --libpath=C:\Keil_v5/ARM/ARMCLANG/lib --diag_suppress=L6314 --diag_suppress=L6329 --predefine="-DSF32LB56X" --predefine="-DARM_MATH_LOOPUNROLL" --predefine="-DSOC_BF0_LCPU" --predefine="-DSIFLI_VERSION=33816576" --predefine="-DLCPU_CONFIG_V1" --predefine="-DUSE_HAL_DRIVER" --predefine="-DSIFLI_BUILD="1e27e0ad"" --predefine="-DHAL_TICK_PER_SECOND=1000" --predefine="-DSF32LB56X" --predefine="-DROM_ENABLED" --predefine="-DRT_USING_ARM_LIBC"
  group Kernel
    ../../../../../rtos/rtthread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group App_utils
    ../../src/lcpu/: main.c
  group activity
    ../../src/modules/algorithm/activity/kraepelin/: activity_algorithm_kraepelin.c
    ../../src/modules/algorithm/activity/: activity.c activity_calculators.c activity_metrics.c activity_sessions.c
  group Algorithm
    ../../src/modules/algorithm/GestureDetect/: gesture_detect.c
    ../../src/modules/algorithm/HandTracking/: hand_tracking.c
    ../../src/modules/algorithm/MahonyAHRS/: sensor_fusion.c
  group Bloc
    ../../src/modules/bloc/: bloc_battery.c bloc_motor.c bloc_peripheral.c bloc_rgb_led.c
  group Service
    ../../src/modules/service/: hr_service.c baro_service.c acce_service.c watch_system_service.c
  group Utils
    ../../src/modules/util/: trig.c list.c math_fixed.c platform.c
    ../../src/modules/util/includes/util/time/: time.c
  group Drivers
    ../../../../../customer/boards/common/: bsp_common.c flash.c
    ../../../../../customer/boards/eh-lb56xu/: bsp_init.c bsp_lcd_tp.c bsp_pinmux.c bsp_power.c bsp_init.c bsp_lcd_tp.c bsp_pinmux.c bsp_power.c bsp_init.c bsp_lcd_tp.c bsp_pinmux.c bsp_power.c
    ../../../../../customer/peripherals/motor/: motor.c
    ../../../../../customer/peripherals/rgb/: drv_rgbled.c
    ../../../../../customer/peripherals/sensor/BMI270-Sensor-API/: bmi2.c bmi270.c bmi270_context.c bmi270_legacy.c bmi270_maximum_fifo.c bmi2_ois.c
    ../../../../../customer/peripherals/sensor/BMI270-Sensor-API/common/: bmi270_driver.c sensor_bmi270.c
    ../../../../../customer/peripherals/sensor/gh3018/: gh3018.c gh30x_example_comm_pkg.c gh30x_example_ctrl.c gh30x_example_hook.c gh30x_example_port.c gh30x_example_process.c gh30x_example_reg_array.c gh30x_hbd_ctrl.c sensor_goodix_gh3018.c
    ../../../../../customer/peripherals/sensor/gh30x_algo/Basic/src/: HRNet_knBasicWeights.c HRNet_knConfNetWeights.c HRNet_knSceneNetWeights.c HRNet_knSceneSwitchWeights.c HRNet_knWeights.c HRNet_knWeightsSmall.c heart_net_org_dll.c pre_v2.1.0_spo2_for_GH3011_N1_basic_730eb8.c
    ../../../../../customer/peripherals/sensor/gh30x_algo_demo/call/src/: gh30x_demo_algo_call_adt.c gh30x_demo_algo_call_hr.c gh30x_demo_algo_call_hrv.c gh30x_demo_algo_call_nadt.c gh30x_demo_algo_call_spo2.c
    ../../../../../customer/peripherals/sensor/gh30x_algo_demo/common/src/: gh30x_demo_algo_call.c gh30x_demo_algo_config.c gh30x_demo_algo_hook.c gh30x_demo_algo_memory.c
    ../../../../../customer/peripherals/sensor/SPL06/: SPL06.c sensor_grt_spl06.c
    ../../../../../rtos/rtthread/bsp/sifli/drivers/: drv_dma.c drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm.c drv_pwm_lptim.c drv_soft_i2c.c drv_i2c.c drv_adc.c drv_rtc.c drv_spi_flash.c drv_spi_nand.c drv_sys_cfg.c drv_wdt.c drv_motor.c drv_psram.c drv_mpi.c drv_common.c drv_dbg.c
  group Drivers
    ../../../../../customer/peripherals/sensor/gh3018/: Default_KEIL5_M33_hard-fp_fshort.lib
    ../../../../../customer/peripherals/sensor/gh30x_algo/Basic/lib/: cortexM33_armcland-mdk531_common.lib cortexM33_armcland-mdk531_hba.lib cortexM33_armcland-mdk531_hrv.lib cortexM33_armcland-mdk531_nadt.lib cortexM33_armcland-mdk531_spo2.lib
  group CMSIS_BF0
    ../../../../../drivers/cmsis/sf32lb56x/: bf0_pin_const.c lcpu_config_type.c
    ../../../../../drivers/cmsis/sf32lb56x/Templates/: system_bf0_ap.c
    ../../../../../drivers/cmsis/sf32lb56x/Templates/arm/: startup_bf0_lcpu.S
  group BF0_HAL
    ../../../../../drivers/hal/: bf0_hal.c bf0_hal_adc.c bf0_hal_aes.c bf0_hal_aes_ns.c bf0_hal_audcodec.c bf0_hal_audprc.c bf0_hal_bleaon.c bf0_hal_busmon.c bf0_hal_cortex.c bf0_hal_crc.c bf0_hal_dma.c bf0_hal_dsi.c bf0_hal_efuse.c bf0_hal_epic.c bf0_hal_ext_dma.c bf0_hal_ezip.c bf0_hal_facc.c bf0_hal_fft.c bf0_hal_gpio.c bf0_hal_hcd.c bf0_hal_hlp.c bf0_hal_hpaon.c bf0_hal_i2c.c bf0_hal_i2s.c bf0_hal_lcdc.c bf0_hal_lcpu_config.c bf0_hal_lpaon.c bf0_hal_lpcomp.c bf0_hal_lptim.c bf0_hal_lrc_cal.c bf0_hal_mailbox.c bf0_hal_mpi.c bf0_hal_mpi_ex.c bf0_hal_mpi_psram.c bf0_hal_nn_acc.c bf0_hal_patch.c bf0_hal_pcd.c bf0_hal_pdm.c bf0_hal_pinmux.c bf0_hal_pmu.c bf0_hal_psram.c bf0_hal_ptc.c bf0_hal_rcc.c bf0_hal_rng.c bf0_hal_rtc.c bf0_hal_sd_ex.c bf0_hal_sdadc.c bf0_hal_sdhci.c bf0_hal_sdmmc.c bf0_hal_secu.c bf0_hal_spi.c bf0_hal_tim.c bf0_hal_tim_ex.c bf0_hal_tsen.c bf0_hal_uart.c bf0_hal_wdt.c bf0_sys_cfg.c flash_table.c nand_table.c sifli_bbm.c
  group BF0_HAL
    ../../../../../drivers/hal/: sifli_rom_56x.sym
  group lib_hal_epic_ex
    ../../../../../drivers/hal_epic_ex/: hal_epic_ex_rvds.lib
  group helper_worker
    ../../../../../external/helper_worker/: helper_worker.c
  group kraepelin_algorithm
    ../../../../../external/Kraepelin/kraepelin_algorithm/: kraepelin_algorithm.c
  group kraepelin_reference
    ../../../../../external/Kraepelin/kraepelin_reference/: ProjectK_worker.c fourier.c raw_stats.c
  group middleware
    ../../../../../middleware/button/: button.c
    ../../../../../middleware/ipc_queue/common/: circular_buf.c ipc_hw.c ipc_queue.c
    ../../../../../middleware/ipc_queue/porting/sf32lb56x/lcpu/: ipc_hw_port.c
  group audio
    ../../../../../middleware/audio/audio_bt_voice/: bt_audiopath.c
    ../../../../../middleware/audio/audio_port/: audio_eq_config.c audio_mem.c audio_pa_api.c
    ../../../../../middleware/audio/audio_voice_proc/: audio_3a_dummy.c
  group rw_rtt
    ../../../../../middleware/bluetooth/porting/rtt/: rw_rtt.c
  group bt
    ../../../../../middleware/bluetooth/service/: bluetooth.c
    ../../../../../middleware/bluetooth/service/internal/: bluetooth_config.c bluetooth_misc.c
  group sifli_bt
    ../../../../../middleware/bluetooth/lib/: dummy.c
  group data_bus
    ../../../../../middleware/data_bus/public/: data_service_main.c data_service.c pin_service.c
  group m_system
    ../../../../../middleware/system/: bf0_common.c
  group os_adapter
    ../../../../../rtos/os_adaptor/src/: os_adaptor_rtthread.c
  group CORTEX-M33
    ../../../../../rtos/rtthread/libcpu/arm/cortex-m33/: cpuport.c context_rvds.S
    ../../../../../rtos/rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../../../rtos/rtthread/components/drivers/hwmailbox/: hwmailbox.c
    ../../../../../rtos/rtthread/components/drivers/hwtimer/: hwtimer.c
    ../../../../../rtos/rtthread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../../../rtos/rtthread/components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../../../rtos/rtthread/components/drivers/motor/: motor_device.c
    ../../../../../rtos/rtthread/components/drivers/rtc/: rtc.c
    ../../../../../rtos/rtthread/components/drivers/serial/: serial.c
    ../../../../../rtos/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../rtos/rtthread/components/drivers/watchdog/: watchdog.c
  group Sensors
    ../../../../../rtos/rtthread/components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    ../../../../../rtos/rtthread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../../../rtos/rtthread/components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c time.c
    ../../../../../rtos/rtthread/components/libc/compilers/common/: gmtime_r.c
  group Utilities
    ../../../../../rtos/rtthread/components/utilities/llt_mem/: llt_mem.c
    ../../../../../rtos/rtthread/components/utilities/ulog/: ulog.c
    ../../../../../rtos/rtthread/components/utilities/ulog/backend/: console_be.c
