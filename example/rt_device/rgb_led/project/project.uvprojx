# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: main
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: LCPU_CONFIG_V1, HAL_USE_NAND, __FILE__=__FILE_NAME__, RT_USING_ARM_LIBC, ARM_MATH_LOOPUNROLL, SIFLI_BUILD="b3b10b58", SOC_BF0_HCPU, SF32LB56X, USE_HAL_DRIVER, HAL_TICK_PER_SECOND=1000, SIFLI_VERSION=33816576
  c misc: -Wno-builtin-macro-redefined
  c include: build_sf32lb56-watch_hcpu;..\..\..\..\rtos\rtthread\include;..\..\..\..\customer\boards\common;..\..\..\..\customer\boards\include;..\..\..\..\customer\boards\include\config\sf32lb56x;..\..\..\..\customer\boards\eh-lb563;..\..\..\..\customer\boards\include;..\..\..\..\customer\boards\eh-lb56xu;..\..\..\..\customer\boards\include;..\..\..\..\customer\boards\sf32lb56-watch;..\..\..\..\customer\boards\include;..\..\..\..\customer\boards\eh-lb56xu;..\..\..\..\customer\boards\include;..\..\..\..\customer\common;..\..\..\..\customer\peripherals\co5300;..\..\..\..\customer\peripherals\common;..\..\..\..\customer\peripherals\cst820;..\..\..\..\customer\peripherals\common;..\..\..\..\customer\peripherals\ft3168;..\..\..\..\customer\peripherals\common;..\..\..\..\customer\peripherals\rgb;..\..\..\..\rtos\rtthread\bsp\sifli\drivers;..\..\..\..\customer\modules\bloc;..\..\..\..\customer\modules\communicate;..\..\..\..\customer\modules\model;..\..\..\..\customer\modules\service;..\..\..\..\customer\modules\tests;..\..\..\..\customer\modules\util\includes;..\..\..\..\drivers\cmsis\sf32lb56x;..\..\..\..\drivers\cmsis\Include;..\..\..\..\external\CMSIS\Include;..\..\..\..\drivers\Include;..\..\..\..\drivers\hal_epic_ex;..\..\..\..\middleware\include;..\..\..\..\middleware\sifli_lib\lib;..\..\..\..\middleware\include;..\..\..\..\rtos\os_adaptor\src;..\..\..\..\rtos\os_adaptor\inc;..\..\..\..\rtos\rtthread\libcpu\arm\cortex-m33;..\..\..\..\rtos\rtthread\libcpu\arm\common;..\..\..\..\rtos\rtthread\components\cplusplus;..\..\..\..\rtos\rtthread\components\dfs\include;..\..\..\..\rtos\rtthread\components\dfs\filesystems\devfs;..\..\..\..\rtos\rtthread\components\dfs\filesystems\dhara\dhara;..\..\..\..\rtos\rtthread\components\drivers\audio;..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\rtos\rtthread\components\drivers\include;..\..\..\..\rtos\rtthread\components\finsh;..\..\..\..\rtos\rtthread\components\libc\compilers\armlibc;..\..\..\..\rtos\rtthread\components\libc\compilers\common\include;..\..\..\..\rtos\rtthread\components\utilities\llt_mem
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  scatter file: build_sf32lb56-watch_hcpu/link.sct
  link misc: --cpu=cortex-m33 --strict --scatter build_sf32lb56-watch_hcpu/link.sct --summary_stderr --info summarysizes --map --load_addr_map_info --xref --callgraph --symbols --info sizes --info totals --info unused --info veneers --any_contingency  --list build_sf32lb56-watch_hcpu/main.map  --libpath=C:\Keil_v5/ARM/ARMCLANG/lib --diag_suppress=L6314 --diag_suppress=L6329 --predefine="-DSF32LB56X" --predefine="-DLCPU_CONFIG_V1" --predefine="-DHAL_USE_NAND" --predefine="-DARM_MATH_LOOPUNROLL" --predefine="-DSIFLI_BUILD="b3b10b58"" --predefine="-DSOC_BF0_HCPU" --predefine="-DSF32LB56X" --predefine="-DUSE_HAL_DRIVER" --predefine="-DHAL_TICK_PER_SECOND=1000" --predefine="-DSIFLI_VERSION=33816576" --predefine="-DRT_USING_ARM_LIBC"
  group Kernel
    ../../../../rtos/rtthread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Drivers
    ../../../../customer/boards/common/: bsp_common.c flash.c
    ../../../../customer/boards/eh-lb56xu/: bsp_init.c bsp_lcd_tp.c bsp_pinmux.c bsp_power.c bsp_init.c bsp_lcd_tp.c bsp_pinmux.c bsp_power.c
    ../../../../customer/peripherals/co5300/: co5300.c
    ../../../../customer/peripherals/cst820/: capacitive_hynitron_CST820_update.c cst820.c cst820_update.c
    ../../../../customer/peripherals/ft3168/: ft3168.c
    ../../../../customer/peripherals/rgb/: drv_rgbled.c
    ../../../../rtos/rtthread/bsp/sifli/drivers/: drv_dma.c drv_gpio.c drv_usart.c drv_hwtimer.c drv_pwm.c drv_pwm_lptim.c drv_i2c.c drv_adc.c drv_rtc.c drv_spi_flash.c drv_spi_nand.c drv_sys_cfg.c drv_ext_dma.c drv_audprc.c drv_audcodec.c drv_lcd_private.c drv_lcd.c drv_ram_lcd.c drv_lcd_test.c drv_lcd_fb.c drv_touch.c drv_epic.c drv_epic_mask.c drv_psram.c drv_mpi.c drv_aes.c drv_common.c drv_dbg.c
  group Utils
    ../../../../customer/modules/util/: trig.c list.c math_fixed.c platform.c
    ../../../../customer/modules/util/includes/util/time/: time.c
  group CMSIS_BF0
    ../../../../drivers/cmsis/sf32lb56x/: bf0_pin_const.c lcpu_config_type.c lcpu_patch.c bf0_lcpu_init.c bt_rf_fulcal.c bt_rf_cw_config.c bt_power_config.c bt_afh_test.c
    ../../../../drivers/cmsis/sf32lb56x/Templates/: system_bf0_ap.c
    ../../../../drivers/cmsis/sf32lb56x/Templates/arm/: startup_bf0_hcpu.S
  group BF0_HAL
    ../../../../drivers/hal/: bf0_hal.c bf0_hal_adc.c bf0_hal_aes.c bf0_hal_aes_ns.c bf0_hal_audcodec.c bf0_hal_audprc.c bf0_hal_bleaon.c bf0_hal_busmon.c bf0_hal_cortex.c bf0_hal_crc.c bf0_hal_dma.c bf0_hal_dsi.c bf0_hal_efuse.c bf0_hal_epic.c bf0_hal_ext_dma.c bf0_hal_ezip.c bf0_hal_facc.c bf0_hal_fft.c bf0_hal_gpio.c bf0_hal_hcd.c bf0_hal_hlp.c bf0_hal_hpaon.c bf0_hal_i2c.c bf0_hal_i2s.c bf0_hal_lcdc.c bf0_hal_lcpu_config.c bf0_hal_lpaon.c bf0_hal_lpcomp.c bf0_hal_lptim.c bf0_hal_lrc_cal.c bf0_hal_mailbox.c bf0_hal_mpi.c bf0_hal_mpi_ex.c bf0_hal_mpi_psram.c bf0_hal_nn_acc.c bf0_hal_patch.c bf0_hal_pcd.c bf0_hal_pdm.c bf0_hal_pinmux.c bf0_hal_pmu.c bf0_hal_psram.c bf0_hal_ptc.c bf0_hal_rcc.c bf0_hal_rng.c bf0_hal_rtc.c bf0_hal_sd_ex.c bf0_hal_sdadc.c bf0_hal_sdhci.c bf0_hal_sdmmc.c bf0_hal_secu.c bf0_hal_spi.c bf0_hal_tim.c bf0_hal_tim_ex.c bf0_hal_tsen.c bf0_hal_uart.c bf0_hal_wdt.c bf0_sys_cfg.c flash_table.c nand_table.c sifli_bbm.c
  group lib_hal_epic_ex
    ../../../../drivers/hal_epic_ex/: hal_epic_ex_rvds.lib
  group m_system
    ../../../../middleware/system/: bf0_common.c
  group os_adapter
    ../../../../rtos/os_adaptor/src/: os_adaptor_rtthread.c
  group Applications
    ../src/: main.c
  group CORTEX-M33
    ../../../../rtos/rtthread/libcpu/arm/cortex-m33/: cpuport.c context_rvds.S
    ../../../../rtos/rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group CPlusPlus
    ../../../../rtos/rtthread/components/cplusplus/: cxx_crt.cpp cxx_mutex.cpp cxx_semaphore.cpp cxx_thread.cpp cxx_crt_init.c
  group Filesystem
    ../../../../rtos/rtthread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../../rtos/rtthread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../../../rtos/rtthread/components/drivers/audio/: audio.c audio_pipe.c
    ../../../../rtos/rtthread/components/drivers/hwtimer/: hwtimer.c
    ../../../../rtos/rtthread/components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../../../rtos/rtthread/components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../../rtos/rtthread/components/drivers/mtd/: mtd_nand.c
    ../../../../rtos/rtthread/components/drivers/rtc/: rtc.c alarm.c
    ../../../../rtos/rtthread/components/drivers/serial/: serial.c
    ../../../../rtos/rtthread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../../rtos/rtthread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../../rtos/rtthread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../../../rtos/rtthread/components/libc/compilers/common/: gmtime_r.c
  group Utilities
    ../../../../rtos/rtthread/components/utilities/llt_mem/: llt_mem.c
